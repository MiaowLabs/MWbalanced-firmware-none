# Keil uVision project MWbalanced.uvproj, settings and files
target MWbalanced (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: MWbalanced +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Appcode;.\BSP;.\Common;.\Driver;.\Startup;.\Common\inc;.\Driver\inc
  group Appcode
    ./Appcode/: includes.h isr.c main.c carstand.c carstand.h
    ./: UpdateLog.txt
  group Driver
    ./Driver/src/: delay.c gpio.c pwm.c timer.c uart.c
  group Common
    ./Common/src/: i2c.c led.c mpu6050.c outputdata.c
  group BSP
    ./BSP/: IAP15W4K61S4.h IOConfig.h
  group Startup
    ./Startup/: STARTUP.A51
