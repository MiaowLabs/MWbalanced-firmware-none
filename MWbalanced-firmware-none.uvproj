# Keil uVision project MWbalanced-firmware-none.uvproj, settings and files
target MWbalanced-firmware-none (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: MWbalanced-firmware-none
  c flags: Optimize=8 SizeSpeed=1
  c include: .\common;.\driver;.\user
  group startup
    ./startup/: STARTUP.A51
  group user
    ./user/: isr.c main.c upstandingcar.c
  group common
    ./common/: i2c.c led.c mpu6050.c outputdata.c
  group driver
    ./driver/: delay.c pwm.c timer.c uart.c
